# Keil uVision project VGA746.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: VGA746
  c flags: Optim=3 oTime=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Board746.cpp main.cpp MyTools.cpp mmc.cpp alu.cpp cmos.cpp cpu.cpp disk.cpp instr.cpp instr_0F.cpp instr32_0F.cpp interrupts.cpp ioports.cpp keybmouse.cpp memdescr.cpp modrm.cpp modrm16.cpp modrm32.cpp pic_pit.cpp stringops.cpp transfer.cpp vga.cpp x86.cpp
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.1.2
